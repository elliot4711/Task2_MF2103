# Keil uVision project RTX_Blinky.uvprojx, settings and files
target STM32L476 Flash (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX_Blinky
  c flags: Optim=6 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x14000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Source Files
    ./: RTX_Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.3.2
